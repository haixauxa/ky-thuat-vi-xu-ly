# Keil uVision project Robot_Car.uvprojx, settings and files
target Robot_Car (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Robot_Car
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM3210X_MD
  c include: ..\inc;..\lib\CMSIS\CM3\CoreSupport;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\STM32F10x_StdPeriph_Driver\src;..\inc\APP_Layer;..\inc\IP_Layer;..\inc\Mid_Layer;..\src\APP_Layer;..\src\IP_Layer;..\src\Mid_Layer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ../src/: main.c
    ../src/IP_Layer/: Ip_Delay.c Ip_Usart.c Ip_Logic.c Ip_Hcsr04.c Ip_Ir_Remote.c Ip_Motor.c Ip_Line_Sensor.c Ip_Line_PID.c Ip_Ring_Buffer.c
    ../src/APP_Layer/: App_Layer.c
    ../src/Mid_Layer/: Mid_Layer.c
  group inc
    ../inc/: main.h
    ../inc/IP_Layer/: Ip_Delay.h Ip_Usart.h Ip_Logic.h Ip_Hcsr04.h Ip_Ir_Remote.h Ip_Motor.h Ip_Line_Sensor.h Ip_Line_PID.h Ip_Ring_Buffer.h
    ../inc/Mid_Layer/: Mid_Layer.h
    ../inc/APP_Layer/: App_Layer.h
  group lib/CMSIS
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../lib/CMSIS/CM3/CoreSupport/: core_cm3.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
